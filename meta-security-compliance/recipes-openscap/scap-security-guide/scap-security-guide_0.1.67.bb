SUMARRY = "SCAP content for various platforms, upstream version"

SRCREV = "ee688320c4478ccb0d4dbefbfbd2f10df6261e17"
SRC_URI = "git://github.com/ComplianceAsCode/content.git;branch=master;protocol=https"

DEFAULT_PREFERENCE = "-1"

require scap-security-guide.inc
